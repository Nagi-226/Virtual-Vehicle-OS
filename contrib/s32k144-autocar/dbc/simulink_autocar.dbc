VERSION

NS_ :

BS_:

BU_: ECU_Motor ECU_CAN ECU_Sensor ECU_Ota

BO_ 100 MotorStatus: 8 ECU_Motor
 SG_ MotorRPM : 0|16@1+ (1,0) (0,65535) "rpm" ECU_CAN,ECU_Sensor
 SG_ MotorTemp : 16|8@1+ (1,-40) (-40,215) "degC" ECU_CAN,ECU_Sensor
 SG_ PhaseCurrentA : 24|16@1- (0.01,-327.68) (-327.68,327.67) "A" ECU_CAN
 SG_ PhaseCurrentB : 40|16@1- (0.01,-327.68) (-327.68,327.67) "A" ECU_CAN
 SG_ FaultCode : 56|8@1+ (1,0) (0,255) "" ECU_CAN,ECU_Sensor

BO_ 200 SensorData: 64 ECU_Sensor
 SG_ RadarSpeed_mps : 0|16@1+ (0.01,0) (0,655.35) "m/s" ECU_Motor,ECU_CAN
 SG_ RadarDistance_mm : 16|16@1+ (1,0) (0,65535) "mm" ECU_Motor,ECU_CAN
 SG_ UltraFront_mm : 32|16@1+ (1,0) (0,65535) "mm" ECU_Motor
 SG_ UltraRear_mm : 48|16@1+ (1,0) (0,65535) "mm" ECU_Motor

BO_ 300 OtaCommand: 8 ECU_Ota
 SG_ CmdType : 0|8@1+ (1,0) (0,255) "" ECU_Motor,ECU_CAN
 SG_ TargetSlot : 8|8@1+ (1,0) (0,1) "" ECU_Motor,ECU_CAN
 SG_ FwSize : 16|32@1+ (1,0) (0,4294967295) "bytes" ECU_Motor
 SG_ Crc32 : 48|32@1+ (1,0) (0,4294967295) "" ECU_Motor

BO_ 400 VehicleControl: 8 ECU_CAN
 SG_ TargetTorque : 0|16@1+ (0.1,-3276.8) (-3276.8,3276.7) "Nm" ECU_Motor
 SG_ TargetSpeed : 16|16@1+ (1,0) (0,65535) "rpm" ECU_Motor
 SG_ RegenLevel : 32|8@1+ (1,0) (0,100) "%" ECU_Motor
 SG_ DriveMode : 40|4@1+ (1,0) (0,15) "" ECU_Motor
 SG_ Enable : 44|1@1+ (1,0) (0,1) "" ECU_Motor

BO_ 500 BmsStatus: 8 ECU_Sensor
 SG_ SocPercent : 0|8@1+ (0.5,0) (0,100) "%" ECU_Motor,ECU_CAN
 SG_ PackVoltage : 8|16@1+ (0.01,0) (0,655.35) "V" ECU_Motor,ECU_CAN
 SG_ PackCurrent : 24|16@1- (0.01,-327.68) (-327.68,327.67) "A" ECU_Motor,ECU_CAN
 SG_ CellTempMax : 40|8@1+ (1,-40) (-40,215) "degC" ECU_CAN
 SG_ CellTempMin : 48|8@1+ (1,-40) (-40,215) "degC" ECU_CAN
 SG_ BmsFault : 56|8@1+ (1,0) (0,255) "" ECU_CAN

BA_DEF_ "GenMsgCycleTime" INT 0 65535;
BA_DEF_DEF_ "GenMsgCycleTime" 0;

BA_ "GenMsgCycleTime" BO_ 100 10;
BA_ "GenMsgCycleTime" BO_ 200 20;
BA_ "GenMsgCycleTime" BO_ 500 100;
